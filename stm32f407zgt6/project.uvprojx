# Keil uVision project project.uvprojx, settings and files
target rt-thread (6140001::V6.14.1::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F407xx, USE_HAL_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, __RTTHREAD__, RT_USING_ARM_LIBC
  c include: applications;board\board_drivers;board\board_drivers\lcd_st7789;board\board_drivers\spi_falsh_w25q64;..\rt-thread\components\libc\compilers\common\include;..\rt-thread\components\libc\compilers\common\extension;..\rt-thread\components\libc\compilers\common\extension\fcntl\octal;..\rt-thread\components\libc\cplusplus;..\rt-thread\libcpu\arm\common;..\rt-thread\libcpu\arm\cortex-m4;..\rt-thread\components\drivers\include;..\rt-thread\components\drivers\include;..\rt-thread\components\drivers\include;..\rt-thread\components\drivers\include;..\rt-thread\components\drivers\include;..\rt-thread\components\drivers\spi;..\rt-thread\components\drivers\include;..\rt-thread\components\drivers\spi\sfud\inc;board;board\CubeMX_Config\Inc;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config;..\libraries\HAL_Drivers\CMSIS\Include;..\libraries\HAL_Drivers\drv_flash;..\rt-thread\components\fal\inc;..\rt-thread\components\dfs\include;..\rt-thread\components\dfs\filesystems\elmfat;..\rt-thread\components\dfs\filesystems\romfs;..\rt-thread\components\finsh;hal;.;..\rt-thread\include;..\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;..\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;..\offline_pkgs\LVGL-v8.3.5\src;..\offline_pkgs\LVGL-v8.3.5\src\core;..\offline_pkgs\LVGL-v8.3.5\src\draw;..\offline_pkgs\LVGL-v8.3.5\src\extra;..\offline_pkgs\LVGL-v8.3.5\src\font;..\offline_pkgs\LVGL-v8.3.5\src\hal;..\offline_pkgs\LVGL-v8.3.5\src\misc;..\offline_pkgs\LVGL-v8.3.5\src\widgets;..\offline_pkgs\LVGL-v8.3.5\src\draw\arm2d;..\offline_pkgs\LVGL-v8.3.5\src\draw\sdl;..\offline_pkgs\LVGL-v8.3.5\src\draw\stm32_dma2d;..\offline_pkgs\LVGL-v8.3.5\src\draw\sw;..\offline_pkgs\LVGL-v8.3.5\src\draw\swm341_dma2d;..\offline_pkgs\LVGL-v8.3.5\src\draw\nxp\pxp;..\offline_pkgs\LVGL-v8.3.5\src\draw\nxp\vglite;..\offline_pkgs\LVGL-v8.3.5\src\extra\layouts;..\offline_pkgs\LVGL-v8.3.5\src\extra\libs;..\offline_pkgs\LVGL-v8.3.5\src\extra\others;..\offline_pkgs\LVGL-v8.3.5\src\extra\themes;..\offline_pkgs\LVGL-v8.3.5\src\extra\widgets;..\offline_pkgs\LVGL-v8.3.5\src\extra\layouts\flex;..\offline_pkgs\LVGL-v8.3.5\src\extra\layouts\grid;..\offline_pkgs\LVGL-v8.3.5\src\extra\libs\bmp;..\offline_pkgs\LVGL-v8.3.5\src\extra\libs\ffmpeg;..\offline_pkgs\LVGL-v8.3.5\src\extra\libs\freetype;..\offline_pkgs\LVGL-v8.3.5\src\extra\libs\fsdrv;..\offline_pkgs\LVGL-v8.3.5\src\extra\libs\gif;..\offline_pkgs\LVGL-v8.3.5\src\extra\libs\png;..\offline_pkgs\LVGL-v8.3.5\src\extra\libs\qrcode;..\offline_pkgs\LVGL-v8.3.5\src\extra\libs\rlottie;..\offline_pkgs\LVGL-v8.3.5\src\extra\libs\sjpg;..\offline_pkgs\LVGL-v8.3.5\src\extra\others\fragment;..\offline_pkgs\LVGL-v8.3.5\src\extra\others\gridnav;..\offline_pkgs\LVGL-v8.3.5\src\extra\others\ime;..\offline_pkgs\LVGL-v8.3.5\src\extra\others\imgfont;..\offline_pkgs\LVGL-v8.3.5\src\extra\others\monkey;..\offline_pkgs\LVGL-v8.3.5\src\extra\others\msg;..\offline_pkgs\LVGL-v8.3.5\src\extra\others\snapshot;..\offline_pkgs\LVGL-v8.3.5\src\extra\themes\basic;..\offline_pkgs\LVGL-v8.3.5\src\extra\themes\default;..\offline_pkgs\LVGL-v8.3.5\src\extra\themes\mono;..\offline_pkgs\LVGL-v8.3.5\src\extra\widgets\animimg;..\offline_pkgs\LVGL-v8.3.5\src\extra\widgets\calendar;..\offline_pkgs\LVGL-v8.3.5\src\extra\widgets\chart;..\offline_pkgs\LVGL-v8.3.5\src\extra\widgets\colorwheel;..\offline_pkgs\LVGL-v8.3.5\src\extra\widgets\imgbtn;..\offline_pkgs\LVGL-v8.3.5\src\extra\widgets\keyboard;..\offline_pkgs\LVGL-v8.3.5\src\extra\widgets\led;..\offline_pkgs\LVGL-v8.3.5\src\extra\widgets\list;..\offline_pkgs\LVGL-v8.3.5\src\extra\widgets\menu;..\offline_pkgs\LVGL-v8.3.5\src\extra\widgets\meter;..\offline_pkgs\LVGL-v8.3.5\src\extra\widgets\msgbox;..\offline_pkgs\LVGL-v8.3.5\src\extra\widgets\span;..\offline_pkgs\LVGL-v8.3.5\src\extra\widgets\spinbox;..\offline_pkgs\LVGL-v8.3.5\src\extra\widgets\spinner;..\offline_pkgs\LVGL-v8.3.5\src\extra\widgets\tabview;..\offline_pkgs\LVGL-v8.3.5\src\extra\widgets\tileview;..\offline_pkgs\LVGL-v8.3.5\src\extra\widgets\win;..\offline_pkgs\LVGL-v8.3.5\demos;..\offline_pkgs\LVGL-v8.3.5\demos\benchmark;..\offline_pkgs\LVGL-v8.3.5\demos\keypad_encoder;..\offline_pkgs\LVGL-v8.3.5\demos\music;..\offline_pkgs\LVGL-v8.3.5\demos\stress;..\offline_pkgs\LVGL-v8.3.5\demos\widgets;..\offline_pkgs\LVGL-v8.3.5\demos\music\assets;board\ports\lvgl;..\offline_pkgs\LVGL-v8.3.5\env_support\rt-thread;..\offline_pkgs\MultiButton;board\ports;board\ports\fal;..\rt-thread\components\libc\posix\io\poll;..\rt-thread\components\libc\posix\io\stdio;..\rt-thread\components\libc\posix\ipc;applications\utils\Reader-beta
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: armv6O0fix.c app.cpp main.cpp
  group board_drivers
    board/board_drivers/spi_falsh_w25q64/: drv_soft_spi_flash.c drv_spi_falsh.c
    board/board_drivers/: drv_filesystem.c
    board/board_drivers/lcd_st7789/: drv_st7789.c
  group Compiler
    ../rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPlusPlus
    ../rt-thread/components/libc/cplusplus/: cxx_Mutex.cpp cxx_crt.cpp cxx_Semaphore.cpp cxx_crt_init.c cxx_Thread.cpp
  group CPU
    ../rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../rt-thread/components/drivers/misc/: pin.c rt_drv_pwm.c
    ../rt-thread/components/drivers/rtc/: rtc.c
    ../rt-thread/components/drivers/sdio/: block_dev.c mmc.c mmcsd_core.c sd.c sdio.c
    ../rt-thread/components/drivers/serial/: serial.c
    ../rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
  group Drivers
    ../libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_pwm.c drv_sdio.c drv_spi.c drv_usart.c
    ../libraries/HAL_Drivers/drv_flash/: drv_flash_f4.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
  group Fal
    ../rt-thread/components/fal/src/: fal_flash.c fal_partition.c fal.c fal_rtt.c
    ../rt-thread/components/fal/samples/porting/: fal_flash_sfud_port.c
  group Filesystem
    ../rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../rt-thread/components/dfs/filesystems/romfs/: dfs_romfs.c romfs.c
    ../rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group hal
    hal/: hal.cpp hal_sdcard.cpp hal_spi_flash.cpp hal_lcd.cpp hal_button.cpp
  group Kernel
    ../rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group Libraries
    ../libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_lptim.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_usart.c stm32f4xx_hal_crc.c stm32f4xx_hal_tim.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rng.c stm32f4xx_hal_cortex.c stm32f4xx_hal_cryp.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal.c stm32f4xx_hal_cec.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_fmc.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group LVGL
    ../offline_pkgs/LVGL-v8.3.5/src/widgets/: lv_checkbox.c lv_roller.c lv_switch.c lv_textarea.c lv_arc.c lv_img.c lv_label.c lv_line.c lv_bar.c lv_btnmatrix.c lv_canvas.c lv_dropdown.c lv_table.c lv_slider.c lv_btn.c lv_objx_templ.c
    ../offline_pkgs/LVGL-v8.3.5/src/core/: lv_indev_scroll.c lv_refr.c lv_theme.c lv_obj_draw.c lv_obj_style_gen.c lv_obj_pos.c lv_disp.c lv_event.c lv_obj.c lv_obj_tree.c lv_group.c lv_obj_style.c lv_indev.c lv_obj_class.c lv_obj_scroll.c
    ../offline_pkgs/LVGL-v8.3.5/src/extra/widgets/win/: lv_win.c
    ../offline_pkgs/LVGL-v8.3.5/demos/music/assets/: img_lv_demo_music_wave_top_large.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_icon_3.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_logo.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_btn_corner_large.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_list_border.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_list_border_large.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_slider_knob.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_cover_2.c img_lv_demo_music_wave_top.c img_lv_demo_music_btn_next.c img_lv_demo_music_corner_right.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_cover_3.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_2.c img_lv_demo_music_corner_left.c img_lv_demo_music_btn_prev.c
    ../offline_pkgs/LVGL-v8.3.5/src/font/: lv_font_montserrat_20.c lv_font_simsun_16_cjk.c lv_font_montserrat_34.c lv_font_montserrat_42.c lv_font_montserrat_24.c lv_font_montserrat_36.c lv_font_montserrat_26.c lv_font_fmt_txt.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_44.c lv_font_montserrat_30.c lv_font_montserrat_46.c lv_font_loader.c lv_font_montserrat_32.c lv_font_montserrat_18.c lv_font_dejavu_16_persian_hebrew.c lv_font_unscii_16.c lv_font_montserrat_40.c lv_font_montserrat_48.c lv_font_montserrat_16.c lv_font_montserrat_22.c lv_font_montserrat_14.c lv_font_montserrat_38.c lv_font_unscii_8.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_12.c lv_font.c lv_font_montserrat_12_subpx.c
    ../offline_pkgs/LVGL-v8.3.5/src/draw/sdl/: lv_draw_sdl_texture_cache.c lv_draw_sdl_img.c lv_draw_sdl_rect.c lv_draw_sdl_utils.c lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_polygon.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_composite.c lv_draw_sdl_mask.c lv_draw_sdl_stack_blur.c lv_draw_sdl_label.c
    ../offline_pkgs/LVGL-v8.3.5/src/extra/libs/png/: lodepng.c lv_png.c
    ../offline_pkgs/LVGL-v8.3.5/demos/music/: lv_demo_music.c lv_demo_music_main.c lv_demo_music_list.c
    ../offline_pkgs/LVGL-v8.3.5/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../offline_pkgs/LVGL-v8.3.5/src/draw/: lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_draw.c lv_img_decoder.c lv_draw_layer.c lv_draw_img.c lv_draw_mask.c lv_draw_arc.c lv_draw_line.c lv_img_cache.c lv_draw_rect.c lv_draw_label.c
    ../offline_pkgs/LVGL-v8.3.5/src/extra/widgets/meter/: lv_meter.c
    ../offline_pkgs/LVGL-v8.3.5/src/misc/: lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c lv_anim.c lv_math.c lv_anim_timeline.c lv_area.c lv_templ.c lv_async.c lv_bidi.c lv_color.c lv_gc.c lv_fs.c lv_ll.c lv_log.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_lru.c lv_timer.c
    ../offline_pkgs/LVGL-v8.3.5/demos/widgets/: lv_demo_widgets.c
    ../offline_pkgs/LVGL-v8.3.5/src/extra/others/msg/: lv_msg.c
    ../offline_pkgs/LVGL-v8.3.5/demos/benchmark/: lv_demo_benchmark.c
    ../offline_pkgs/LVGL-v8.3.5/src/draw/sw/: lv_draw_sw.c lv_draw_sw_img.c lv_draw_sw_blend.c lv_draw_sw_layer.c lv_draw_sw_transform.c lv_draw_sw_dither.c lv_draw_sw_arc.c lv_draw_sw_gradient.c lv_draw_sw_polygon.c lv_draw_sw_line.c lv_draw_sw_letter.c lv_draw_sw_rect.c
    ../offline_pkgs/LVGL-v8.3.5/src/extra/others/imgfont/: lv_imgfont.c
    ../offline_pkgs/LVGL-v8.3.5/src/extra/widgets/keyboard/: lv_keyboard.c
    ../offline_pkgs/LVGL-v8.3.5/src/extra/themes/basic/: lv_theme_basic.c
    ../offline_pkgs/LVGL-v8.3.5/src/extra/: lv_extra.c
    ../offline_pkgs/LVGL-v8.3.5/src/draw/arm2d/: lv_gpu_arm2d.c
    ../offline_pkgs/LVGL-v8.3.5/src/extra/themes/default/: lv_theme_default.c
    ../offline_pkgs/LVGL-v8.3.5/demos/benchmark/assets/: img_benchmark_cogwheel_rgb565a8.c img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_indexed16.c lv_font_bechmark_montserrat_16_compr_az.c.c img_benchmark_cogwheel_chroma_keyed.c img_benchmark_cogwheel_rgb.c lv_font_bechmark_montserrat_28_compr_az.c.c img_benchmark_cogwheel_argb.c lv_font_bechmark_montserrat_12_compr_az.c.c
    ../offline_pkgs/LVGL-v8.3.5/src/extra/libs/freetype/: lv_freetype.c
    ../offline_pkgs/LVGL-v8.3.5/src/extra/widgets/msgbox/: lv_msgbox.c
    ../offline_pkgs/LVGL-v8.3.5/demos/stress/: lv_demo_stress.c
    ../offline_pkgs/LVGL-v8.3.5/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../offline_pkgs/LVGL-v8.3.5/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../offline_pkgs/LVGL-v8.3.5/src/extra/widgets/animimg/: lv_animimg.c
    ../offline_pkgs/LVGL-v8.3.5/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../offline_pkgs/LVGL-v8.3.5/src/extra/others/ime/: lv_ime_pinyin.c
    ../offline_pkgs/LVGL-v8.3.5/src/extra/widgets/spinner/: lv_spinner.c
    ../offline_pkgs/LVGL-v8.3.5/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_dropdown.c lv_calendar_header_arrow.c
    ../offline_pkgs/LVGL-v8.3.5/src/extra/widgets/menu/: lv_menu.c
    ../offline_pkgs/LVGL-v8.3.5/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../offline_pkgs/LVGL-v8.3.5/src/extra/libs/fsdrv/: lv_fs_win32.c lv_fs_stdio.c lv_fs_fatfs.c lv_fs_posix.c
    ../offline_pkgs/LVGL-v8.3.5/src/extra/widgets/chart/: lv_chart.c
    ../offline_pkgs/LVGL-v8.3.5/src/draw/nxp/pxp/: lv_draw_pxp.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c lv_draw_pxp_blend.c
    ../offline_pkgs/LVGL-v8.3.5/src/extra/themes/mono/: lv_theme_mono.c
    ../offline_pkgs/LVGL-v8.3.5/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../offline_pkgs/LVGL-v8.3.5/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../offline_pkgs/LVGL-v8.3.5/demos/widgets/assets/: img_lvgl_logo.c img_clothes.c img_demo_widgets_avatar.c
    ../offline_pkgs/LVGL-v8.3.5/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../offline_pkgs/LVGL-v8.3.5/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_rect.c lv_draw_vglite_line.c lv_vglite_buf.c lv_vglite_utils.c
    ../offline_pkgs/LVGL-v8.3.5/src/extra/libs/bmp/: lv_bmp.c
    ../offline_pkgs/LVGL-v8.3.5/src/extra/widgets/list/: lv_list.c
    ../offline_pkgs/LVGL-v8.3.5/demos/keypad_encoder/: lv_demo_keypad_encoder.c
    ../offline_pkgs/LVGL-v8.3.5/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../offline_pkgs/LVGL-v8.3.5/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../offline_pkgs/LVGL-v8.3.5/src/extra/libs/rlottie/: lv_rlottie.c
    ../offline_pkgs/LVGL-v8.3.5/src/extra/widgets/tabview/: lv_tabview.c
    ../offline_pkgs/LVGL-v8.3.5/src/extra/layouts/flex/: lv_flex.c
    ../offline_pkgs/LVGL-v8.3.5/src/extra/widgets/span/: lv_span.c
    ../offline_pkgs/LVGL-v8.3.5/src/extra/others/snapshot/: lv_snapshot.c
    ../offline_pkgs/LVGL-v8.3.5/src/extra/widgets/spinbox/: lv_spinbox.c
    ../offline_pkgs/LVGL-v8.3.5/src/extra/layouts/grid/: lv_grid.c
    ../offline_pkgs/LVGL-v8.3.5/src/extra/widgets/led/: lv_led.c
    ../offline_pkgs/LVGL-v8.3.5/src/extra/others/monkey/: lv_monkey.c
    ../offline_pkgs/LVGL-v8.3.5/src/extra/others/gridnav/: lv_gridnav.c
    ../offline_pkgs/LVGL-v8.3.5/src/extra/widgets/tileview/: lv_tileview.c
  group LVGL-port
    board/ports/lvgl/: lv_port_disp.cpp lv_port_fs.cpp lv_port_indev.cpp
    ./board/ports/lvgl/: lv_port.cpp
    ../offline_pkgs/LVGL-v8.3.5/env_support/rt-thread/: lv_rt_thread_port.cpp
  group MultiButton
    ../offline_pkgs/MultiButton/: multi_button.c
  group ports
    board/ports/fal/: fal_spi_flash_sfud_port.c
  group Reader
    applications/utils/Reader-beta/: Reader.cpp
